# Keil uVision project STM32-MRF24WB.uvproj, settings and files
target STM32-MRF24WB (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-MRF24WB
  c flags: Optim=1 OneElfS=1
  c define: CFG_INCLUDE_MapleRET6_MRF24WB STM32F10X
  c include: .\;.\Configs;..\..\Microchip\Include;"..\..\Microchip\Include\TCPIP Stack";..\..\STM\MapleRET6;..\..\STM\CMSIS\CM3\DeviceSupport;..\..\STM\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group TCPIP Stack
    ../../Microchip/TCPIP Stack/: Helpers.c Delay.c Tick.c StackTsk.c MPFS2.c ICMP.c HTTP2.c DNS.c UDP.c ARP.c AutoIP.c TCP.c DHCP.c IP.c Announce.c Reboot.c Hashes.c
  group Wi-Fi
    ./: WF_Config.c
    ../../Microchip/TCPIP Stack/WiFi/: WF_Eint.c WF_Spi.c WFConnectionAlgorithm.c WFConnectionManager.c WFConnectionProfile.c WFConsole.c WFConsoleIfconfig.c WFConsoleIwconfig.c WFConsoleIwpriv.c WFConsoleMsgHandler.c WFConsoleMsgs.c WFDataTxRx.c WFDriverCom.c WFDriverRaw.c WFEasyConfig.c WFEventHandler.c WFInit.c WFMac.c WFMgmtMsg.c WFParamMsg.c WFPowerSave.c WFScan.c WFTxPower.c
  group Application
    ./: CustomHTTPApp.c MainDemo.c PingDemo.c MPFSImg2.c UARTConfig.c UART.c
  group Headers
    ./: HardwareProfile.h HTTPPrint.h MainDemo.h TCPIPConfig.h WF_Config.h
    ./Configs/: HWP STM32 MRF24WB.h TCPIP STM32 MRF24WB.h HWP STM32VL-DISC MRF24WB.h
  group STM32
    ../../STM/MapleRET6/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c startup_stm32f10x_hd.s
    ../../STM/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_flash.c
