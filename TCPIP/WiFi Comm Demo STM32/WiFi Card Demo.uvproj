# Keil uVision project WiFi Card Demo.uvproj, settings and files
target STM32 - WiFi Card Demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WiFi Card Demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\Microchip\Include;..\..\STM;..\..\STM\STM32F10x_StdPeriph_Driver\inc;..\..\STM\CMSIS\CM3\DeviceSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: MainDemo.c CustomHTTPApp.c IperfApp.c MPFSImg2.c WF_Config.c
  group Headers
    ./: HardwareProfile.h HTTPPrint.h IperfApp.h MainDemo.h TCPIPConfig.h WF_Config.h
  group TCPIP Stack
    ../../Microchip/TCPIP Stack/: Delay.c ICMP.c MPFS2.c StackTsk.c Tick.c TCP.c UDP.c HTTP2.c IP.c Helpers.c Hashes.c ARP.c DNS.c UART.c Reboot.c DHCP.c ZeroconfLinkLocal.c DHCPs.c DNSs.c Announce.c NBNS.c Telnet.c
  group Wi-Fi
    ../../Microchip/TCPIP Stack/WiFi/: WF_Eint.c WF_Spi.c WFDriverCom.c WFDriverRaw.c WFEasyConfig.c WFInit.c WFMac.c WFScan.c WFConnectionAlgorithm.c WFConnectionManager.c WFConnectionProfile.c WFConsole.c WFConsoleIfconfig.c WFConsoleIwconfig.c WFConsoleIwpriv.c WFConsoleMsgHandler.c WFConsoleMsgs.c WFDataTxRx.c WFEventHandler.c WFMgmtMsg.c WFParamMsg.c WFPowerSave.c WFTxPower.c WFDebugStrings.c
  group STM32
    ../../STM/: startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h system_stm32f10x.c
    ../../STM/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_spi.c
