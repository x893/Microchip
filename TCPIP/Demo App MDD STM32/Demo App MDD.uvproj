# Keil uVision project Demo App MDD.uvproj, settings and files
target MAPLE-R6 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MAPLE-R6
  c flags: Optim=2 OneElfS=1
  c include: .\;..\..\Microchip\Include;..\..\STM;..\..\STM\STM32F10x_StdPeriph_Driver\inc;..\..\STM\CMSIS\CM3\DeviceSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./: MainDemo.c BerkeleyTCPClientDemo.c BerkeleyTCPServerDemo.c BerkeleyUDPClientDemo.c CustomHTTPApp.c CustomSSLCert.c GenericTCPClient.c GenericTCPServer.c HTTP2_MDD.c PingDemo.c SMTPDemo.c UARTConfig.c WF_Config.c
    ../../Microchip/TCPIP Stack/: UART.c
  group Headers
    ./: FSconfig.h HardwareProfile.h HTTPPrint.h MainDemo.h mib.h TCPIPConfig.h
  group MDD File System
    ../../Microchip/MDD File System/: FSIO.c SD-SPI.c
  group TCPIP Stack
    ../../Microchip/TCPIP Stack/: DNS.c ICMP.c Helpers.c Hashes.c SMTP.c TCP.c StackTsk.c UDP.c FileSystem.c Tick.c ARP.c IP.c DHCP.c Delay.c Reboot.c Announce.c
  group Wi-Fi
    ../../Microchip/TCPIP Stack/WiFi/: WFMac.c WF_Eint.c WF_Spi.c WFDriverCom.c WFDriverRaw.c WFInit.c WFEasyConfig.c WFPowerSave.c WFDebugStrings.c WFConnectionManager.c WFMgmtMsg.c WFEventHandler.c WFParamMsg.c WFConnectionAlgorithm.c WFConnectionProfile.c WFScan.c
  group STM32
    ../../STM/: startup_stm32f10x_hd.s startup_stm32f10x_md_vl.s system_stm32f10x.c stm32f10x.h stm32f10x_conf.h
    ../../STM/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_adc.c
target STM32VL-DISCOVERY (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32VL-DISCOVERY
  c flags: Optim=2 OneElfS=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
