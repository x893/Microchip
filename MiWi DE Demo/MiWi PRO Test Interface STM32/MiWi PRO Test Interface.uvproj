# Keil uVision project MiWi PRO Test Interface.uvproj, settings and files
target MiWi PRO Test Interface (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MiWi PRO Test Interface
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32VLDISCOVERY __STM32F10X__
  c include: .\;..\..\Microchip\Include;..\..\Microchip\Include\WirelessProtocols;..\..\Microchip\Include\WirelessProtocols\MiWiPRO;..\..\Microchip\Include\WirelessProtocols\MiWi;..\..\Microchip\Include\WirelessProtocols\P2P;..\..\Microchip\Include\Transceivers;..\..\Microchip\Include\Transceivers\MRF24J40;..\..\Microchip\Include\Transceivers\MRF49XA;..\..\Microchip\Include\Transceivers\MRF89XA;..\..\STM;..\..\STM\CMSIS\CM3\DeviceSupport;..\..\STM\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: HardwareProfile.c MiWi PRO Test Interface.c
  group Headers
    ./: ConfigApp.h HardwareProfile.h SystemProfile.h Config.h
  group Common
    ../../Microchip/Common/: TimeDelay.c
  group Protocols
    ../../Microchip/WirelessProtocols/: Console.c MSPI.c NVM.c SymbolTime.c
    ../../Microchip/WirelessProtocols/MiWi/: MiWi.c
    ../../Microchip/WirelessProtocols/MiWiPRO/: MiWiPRO.c
    ../../Microchip/WirelessProtocols/P2P/: P2P.c
  group Transceivers
    ../../Microchip/Transceivers/: crc.c security.c
    ../../Microchip/Transceivers/MRF24J40/: MRF24J40.c
    ../../Microchip/Transceivers/MRF49XA/: MRF49XA.c
    ../../Microchip/Transceivers/MRF89XA/: MRF89XA.c
  group STM32
    ../../STM/: stm32f10x.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
    ../../STM/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c
